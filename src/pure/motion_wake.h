// Решение «движение будит погашенный экран».
//
// Вынесено из прошивки отдельным модулем, потому что проверить это руками
// трудно: нужно трясти устройство. Логика же неочевидная — акселерометр шумит,
// а сразу после лёгкого сна первый отсчёт вообще бывает мусорным (в логе
// ловилось 0.12 g), и такой мусор будил экран бесконечно.
//
// Поэтому: заведомо неверные отсчёты отбрасываем, а на пробуждение требуем
// несколько попаданий подряд — одно движение даёт серию отсчётов, а сбой
// чтения один.
//
// Модуль чистый: ни Arduino, ни датчика, проверяется обычными тестами.
#pragma once

#include <cstdint>

namespace motion {

struct Wake {
  float   pickupG;  // порог «подняли»: в покое 1 g, при подъёме заметно больше
  uint8_t need;     // сколько попаданий подряд достаточно для пробуждения
  float   saneMin;  // ниже этого отсчёт физически невозможен — это сбой

  Wake(float pickup = 1.35f, uint8_t need = 3, float saneMin = 0.5f)
      : pickupG(pickup), need(need), saneMin(saneMin), hits_(0) {}

  // Один отсчёт модуля ускорения (в g). true — пора будить экран.
  bool feed(float mag) {
    // Покой — ровно 1 g. Значение у нуля означает сбой чтения, а не движение:
    // именно такой мусор раньше будил экран и не давал ему остаться погашенным.
    if (mag < saneMin) {
      hits_ = 0;
      return false;
    }
    if (mag > pickupG || mag < 1.0f / pickupG) {
      if (++hits_ < need) return false;
      hits_ = 0;
      return true;
    }
    hits_ = 0;
    return false;
  }

 private:
  uint8_t hits_;
};

}  // namespace motion
